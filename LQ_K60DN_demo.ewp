# IAR project LQ_K60DN_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: Z:\毕业设计\VG版 带Z  K60DN512ZVLQ10核心板\2.发货前测试程序\LQ_K60DN_demo\src\User; Z:\毕业设计\VG版 带Z  K60DN512ZVLQ10核心板\2.发货前测试程序\LQ_K60DN_demo\src\Includes; Z:\毕业设计\VG版 带Z  K60DN512ZVLQ10核心板\2.发货前测试程序\LQ_K60DN_demo\src\libs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K60.bin
  ILINK.IlinkOutputFile: LQ_K60DN_demo.out
  ILINK.IlinkIcfFile: Z:\毕业设计\VG版 带Z  K60DN512ZVLQ10核心板\2.发货前测试程序\LQ_K60DN_demo\src\Project_Setting\Linker_Files\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: Z:\毕业设计\VG版 带Z  K60DN512ZVLQ10核心板\2.发货前测试程序\LQ_K60DN_demo\src\Includes; Z:\毕业设计\VG版 带Z  K60DN512ZVLQ10核心板\2.发货前测试程序\LQ_K60DN_demo\src\User; Z:\毕业设计\VG版 带Z  K60DN512ZVLQ10核心板\2.发货前测试程序\LQ_K60DN_demo\src\libs
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: LQ_K60DN_demo.hex
  group Driver/ADC
    src/Source/: ADC.c
    src/Includes/: ADC.h
  group Driver/common
    src/Source/: common.c
    src/Includes/: common.h
    //vmware-host/Shared Folders/毕业设计/VG版 带Z  K60DN512ZVLQ10核心板/2.发货前测试程序/LQ_K60DN_demo/src/: Includes
  group Driver/DAC
    src/Source/: DAC.c
    src/Includes/: DAC.h
  group Driver/DMA
    src/Source/: DMA.c
    src/Includes/: DMA.h
  group Driver/FTM
    src/Source/: FTM.c
    src/Includes/: FTM.h
  group Driver/GPIO
    src/Source/: GPIO.c
    src/Includes/: GPIO.h GPIO_Cfg.h
  group Driver/I2C
    src/Source/: I2C.c
    src/Includes/: I2C.h
  group Driver/Lptmr
    src/Source/: Lptmr.c
    src/Includes/: Lptmr.h
  group Driver/LQKEY
    src/Source/: LQKEY.c
    src/Includes/: LQKEY.h
  group Driver/LQLED
    src/Source/: LQLED.c
    src/Includes/: LQLED.h
  group Driver/PIT
    src/Source/: PIT.c
    src/Includes/: PIT.h
  group Driver/PLL
    src/Source/: PLL.c
    src/Includes/: PLL.h
  group Driver/UART
    src/Source/: UART.c
    src/Includes/: UART.h
  group Driver/Vectors
    src/Source/: vectors.c
    src/Includes/: vectors.h
  group Driver/Wdog
    src/Source/: wdog.c
    src/Includes/: wdog.h
  group Libs
    src/Libs/: MK60N512VMD100.h
  group Project_Setting/Linker_Files
    src/Project_Setting/Linker_Files/: Pflash.icf
  group Project_Setting/Startup
    src/Project_Setting/Startup/: crt0.s start.c
  group User
    src/User/: include.h LQ12864.c LQ12864.h main.c
