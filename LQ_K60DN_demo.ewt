<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Driver</name>
    <group>
      <name>ADC</name>
      <file>
        <name>$PROJ_DIR$\src\Source\ADC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\ADC.h</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\src\Source\common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\common.h</name>
      </file>
    </group>
    <group>
      <name>DAC</name>
      <file>
        <name>$PROJ_DIR$\src\Source\DAC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\DAC.h</name>
      </file>
    </group>
    <group>
      <name>DMA</name>
      <file>
        <name>$PROJ_DIR$\src\Source\DMA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\DMA.h</name>
      </file>
    </group>
    <group>
      <name>FTM</name>
      <file>
        <name>$PROJ_DIR$\src\Source\FTM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\FTM.h</name>
      </file>
    </group>
    <group>
      <name>GPIO</name>
      <file>
        <name>$PROJ_DIR$\src\Source\GPIO.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\GPIO.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\GPIO_Cfg.h</name>
      </file>
    </group>
    <group>
      <name>I2C</name>
      <file>
        <name>$PROJ_DIR$\src\Source\I2C.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\I2C.h</name>
      </file>
    </group>
    <group>
      <name>Lptmr</name>
      <file>
        <name>$PROJ_DIR$\src\Source\Lptmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\Lptmr.h</name>
      </file>
    </group>
    <group>
      <name>LQKEY</name>
      <file>
        <name>$PROJ_DIR$\src\Source\LQKEY.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\LQKEY.h</name>
      </file>
    </group>
    <group>
      <name>LQLED</name>
      <file>
        <name>$PROJ_DIR$\src\Source\LQLED.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\LQLED.h</name>
      </file>
    </group>
    <group>
      <name>PIT</name>
      <file>
        <name>$PROJ_DIR$\src\Source\PIT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\PIT.h</name>
      </file>
    </group>
    <group>
      <name>PLL</name>
      <file>
        <name>$PROJ_DIR$\src\Source\PLL.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\PLL.h</name>
      </file>
    </group>
    <group>
      <name>UART</name>
      <file>
        <name>$PROJ_DIR$\src\Source\UART.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\UART.h</name>
      </file>
    </group>
    <group>
      <name>Vectors</name>
      <file>
        <name>$PROJ_DIR$\src\Source\vectors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\vectors.h</name>
      </file>
    </group>
    <group>
      <name>Wdog</name>
      <file>
        <name>$PROJ_DIR$\src\Source\wdog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Includes\wdog.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Libs</name>
    <file>
      <name>$PROJ_DIR$\src\Libs\MK60N512VMD100.h</name>
    </file>
  </group>
  <group>
    <name>Project_Setting</name>
    <group>
      <name>Linker_Files</name>
      <file>
        <name>$PROJ_DIR$\src\Project_Setting\Linker_Files\Pflash.icf</name>
      </file>
    </group>
    <group>
      <name>Startup</name>
      <file>
        <name>$PROJ_DIR$\src\Project_Setting\Startup\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\src\Project_Setting\Startup\start.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\src\User\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\User\LQ12864.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\User\LQ12864.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\User\main.c</name>
    </file>
  </group>
</project>


